## drivers/net/wireless/realtek/rtl8188eus/Kconfig
```kconfig
config RTL8188EU
	tristate "Realtek 8188E USB WiFi"
	depends on USB
	help
	  Realtek RTL8188EU/EUS USB wireless LAN driver.
```
